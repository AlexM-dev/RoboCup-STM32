# Keil uVision project Lower_board.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: .DOT.X_Lower_board
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp
  c include: .\src\spl;.\src\pins;.\src\main;.\src\miltiplexer;.\src\dma;.\src\adc;.\src\uart;.\src\global_macros;.\src\spi
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./src/main/: main.cpp project_config.h
  group multiplexer
    ./src/miltiplexer/: multiplexer.cpp multiplexer.h
  group pins
    ./src/pins/: pins_setup.h pin_setup.cpp
  group spl
    ./src/spl/: stm32f10x_tim.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_usart.c
  group adc
    ./src/adc/: adc.cpp adc.h
  group dma
    ./src/dma/: dma.cpp dma.h
  group usart
    ./src/uart/: uart.cpp uart.h
  group global_macros
    ./src/global_macros/: global_macros.h stm32f1xx_global_macros.h
  group spi
    ./src/spi/: stm32f103_pin.cpp stm32f103_pin.h stm32f103_pinList.h stm32f103_SPI.c stm32f103_SPI.h stm32f103_sysFunc.cpp stm32f103_sysFunc.h stm32f103_wrappers.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0
