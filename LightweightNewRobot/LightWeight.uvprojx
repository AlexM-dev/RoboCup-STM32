# Keil uVision project LightWeight.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LightWeight
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,STM32F40_41xxx, USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, HSE_VALUE = 12000000
  c include: .\src\adc;.\src\cmsis;.\src\dma;.\src\external;.\src\global_macros;.\src\main;.\src\motion_control;.\src\motor_control;.\src\pins;.\src\softI2C;.\src\time_service;.\src\uart;.\src\spl4\inc;.\src\spl4\src;.\src\spl4;.\src\support_pacage;.\src\support_pacage\inc;.\src\support_pacage\gcc;.\src\support_pacage\arm;.\src\mathematics;.\src\ballDetection;.\src\buttonsModule;.\src\usart;.\src\strategy;.\src\usart6;.\src\usart2;.\src\usart1;.\src\gyroscope;.\src\camera;.\src\lower_board;.\src\IRlocator;.\src\usart3;.\src\bluetooth_send;.\src\bluetooth_robot;.\src\oled;.\src\gyroscope;.\src\SPI;.\src\uart4;.\src\gyroscope;.\src\lineSensors;.\src\gyroUART;.\src\multiplexer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group adc
    ./src/adc/: adc.cpp adc.h
  group dma
    ./src/dma/: dma.h dma.cpp
  group global_macros
    ./src/global_macros/: stm32f4xx_global_macros.h global_macros.h qt_global_macros.h
  group spl
    ./src/spl4/src/: stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_gpio.c misc.c
  group pins
    ./src/pins/: pin_setup.cpp pins_setup.h
  group motor_control
    ./src/motor_control/: motor_control.h motor_control.cpp
  group time_service
    ./src/time_service/: time_service.h time_service.cpp
  group softI2C
    ./src/softI2C/: softI2C.cpp softI2C.h
  group main
    ./src/main/: main.cpp project_config.h RTE_Device.h startup_stm32f407xx.s
    ./src/external/: retarget.cpp
    ./src/support_pacage/: system_stm32f4xx.c
  group mathematics
    ./src/mathematics/: mathematics.cpp mathematics.h
  group motion_control
    ./src/motion_control/: motion_control.cpp motion_control.h
  group ballDetection
    ./src/ballDetection/: ballDetection.cpp ballDetection.h
  group strategy
    ./src/strategy/: strategy.cpp strategy.h
  group buttonsModule
    ./src/buttonsModule/: buttonsModule.h buttonsModule.cpp
  group usart3
    ./src/usart3/: usart3.cpp usart3.h
  group usart6
    ./src/usart6/: usart6.cpp usart6.h
  group usart2
    ./src/usart2/: usart2.cpp usart2.h
  group usart1
    ./src/usart1/: usart1.h usart1.cpp
  group gyroscope
    ./src/gyroscope/: font.h mpu9250.cpp mpu9250.h mpu9250_registers.h stm32f407_adc.cpp stm32f407_adc.h stm32f407_pin.cpp stm32f407_pin.h stm32f407_pinList.h stm32f407_PWM.cpp stm32f407_PWM.h stm32f407_sysFunc.cpp stm32f407_sysFunc.h stm32f407_wrappers.h
  group camera
    ./src/camera/: camera.h camera.cpp
  group lower_board
    ./src/lower_board/: lower_board.cpp lower_board.h
  group ultrasonic
    ./src/ultrasonic/: ultrasonic.cpp ultrasonic.h
  group IRlocator
    ./src/IRlocator/: IRlocator.cpp IRlocator.h
  group bluetooth_send
    ./src/bluetooth_send/: bluetooth_send.h bluetooth_send.cpp
  group bluetooth_robot
    ./src/bluetooth_robot/: bluetooth_robot.cpp bluetooth_robot.h
  group oled
    ./src/oled/: ssd1306_fonts.h ssd1306_fonts.c ssd1306_conf_template.h
  group SPI
    ./src/SPI/: stm32f407_SPI.cpp stm32f407_SPI.h
  group uart4
    ./src/uart4/: uart4.cpp uart4.h
  group line_sensors
    ./src/lineSensors/: line_sensors.cpp line_sensors.h
  group gyroUART
    ./src/gyroUART/: gyro.cpp gyro.h
  group multiplexer
    ./src/multiplexer/: multiplexer.cpp multiplexer.h
